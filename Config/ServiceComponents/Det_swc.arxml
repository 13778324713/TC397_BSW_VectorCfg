<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00046.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="abd52374-66a0-4b1f-a5b9-8e55927c7726">
          <SHORT-NAME>Det_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="01c2f5f0-ed7e-43a3-bfb2-13d7b4fca53e">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="e16da0f4-a5f0-4434-b42c-1fcfc14d6df4">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
